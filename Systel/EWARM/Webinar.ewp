# IAR project Webinar.ewp, settings and files
configuration STM32F746G-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_BPP=24
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ../TouchGFX/target; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/gui/include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\Drivers\BSP\STM32746G-Discovery; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32F746G-DISCO.hex
  ILINK.IlinkOutputFile: STM32F746G-DISCO.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.cpp stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c main.cpp freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp HW_Init.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7Instrumentation.cpp STM32F7TouchController.cpp BoardConfiguration.cpp GPIO.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7TouchController.cpp STM32F7Instrumentation.cpp HW_Init.cpp
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp Font_verdana_10_4bpp.cpp Font_verdana_20_4bpp.cpp Font_verdana_32_4bpp.cpp Font_verdana_40_4bpp.cpp FontGetters.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_32_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_32_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/analog_screen
    ../TouchGFX/generated/gui_generated/src/analog_screen/: analogViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: CustomContainer1Base.cpp
  group Application/User/TouchGFX/generated/gui_generated/homescreen_screen
    ../TouchGFX/generated/gui_generated/src/homescreen_screen/: HomeScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/numeric_screen
    ../TouchGFX/generated/gui_generated/src/numeric_screen/: NumericViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/speech_screen
    ../TouchGFX/generated/gui_generated/src/speech_screen/: SpeechViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/splash_screen
    ../TouchGFX/generated/gui_generated/src/splash_screen/: SplashViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: AnalogIcon.cpp background.cpp BinaryIcon.cpp BitmapDatabase.cpp logo-supcom.cpp NumericIcon.cpp SpeechIcon.cpp STLogo.cpp supcom.cpp Webp.net-resizeimage.cpp
  group Application/User/TouchGFX/generated/images/__designer
    ../TouchGFX/generated/images/src/__designer/: blue_icons_home_48.cpp dark_buttons_round_icon_button.cpp dark_buttons_round_icon_button_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/analog_screen
    ../TouchGFX/gui/src/analog_screen/: AnalogPresenter.cpp AnalogView.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: CustomContainer1.cpp
  group Application/User/TouchGFX/gui/homescreen_screen
    ../TouchGFX/gui/src/homescreen_screen/: HomeScreenPresenter.cpp HomeScreenView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/numeric_screen
    ../TouchGFX/gui/src/numeric_screen/: NumericPresenter.cpp NumericView.cpp
  group Application/User/TouchGFX/gui/speech_screen
    ../TouchGFX/gui/src/speech_screen/: SpeechPresenter.cpp SpeechView.cpp
  group Application/User/TouchGFX/gui/splash_screen
    ../TouchGFX/gui/src/splash_screen/: SplashPresenter.cpp SplashView.cpp
  group Drivers/BSP
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_qspi.c stm32746g_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s port.c portasm.s
  group Middlewares/TouchGFX
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp OSWrappers.cpp
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a touchgfx_core_release.a
